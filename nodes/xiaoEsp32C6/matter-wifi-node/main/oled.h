#pragma once

#include "driver/i2c_master.h"

#include <cstring>

class Oled {
public:
    bool init(i2c_master_bus_handle_t bus)
    {
        constexpr uint8_t address = 0x3c;
        if (!bus || i2c_master_probe(bus, address, 50) != ESP_OK) {
            return false;
        }
        i2c_device_config_t config{};
        config.dev_addr_length = I2C_ADDR_BIT_LEN_7;
        config.device_address = address;
        config.scl_speed_hz = 400000;
        if (i2c_master_bus_add_device(bus, &config, &device_) != ESP_OK) {
            return false;
        }
        // SSD1306, internal charge pump and horizontal addressing.
        const uint8_t setup[] = {0x00, 0xae, 0xd5, 0x80, 0xa8, 63, 0xd3, 0,
                                 0x40, 0x8d, 0x14, 0x20, 0, 0xa1, 0xc8,
                                 0xda, 0x12, 0x81, 0x50, 0xd9, 0x22, 0xdb,
                                 0x40, 0xa4, 0xa6, 0x2e};
        const uint8_t on[] = {0x00, 0xaf};
        if (send(setup, sizeof(setup)) && show() && send(on, sizeof(on))) {
            return true;
        }
        i2c_master_bus_rm_device(device_);
        device_ = nullptr;
        return false;
    }

    void clear()
    {
        std::memset(frame_ + 1, 0, sizeof(frame_) - 1);
    }

    void text(int x, int y, const char *message, int scale = 1)
    {
        for (; *message && x + 5 * scale <= 128; ++message, x += 6 * scale) {
            const auto *rows = glyph(*message);
            if (!rows) {
                continue;
            }
            for (int dy = 0; dy < 7 * scale; ++dy) {
                for (int dx = 0; dx < 5 * scale; ++dx) {
                    if (rows[dy / scale] & (0x10 >> (dx / scale))) {
                        pixel(x + dx, y + dy);
                    }
                }
            }
        }
    }

    void pixel(int x, int y)
    {
        if (x >= 0 && x < 128 && y >= 0 && y < 64) {
            frame_[1 + (y / 8) * 128 + x] |= 1u << (y % 8);
        }
    }

    bool show()
    {
        const uint8_t window[] = {0x00, 0x21, 0, 127, 0x22, 0, 7};
        if (!send(window, sizeof(window))) {
            return false;
        }
        // Release the shared I2C bus between short transfers for accelerometer reads.
        uint8_t packet[129] = {0x40};
        for (unsigned page = 0; page < 8; ++page) {
            std::memcpy(packet + 1, frame_ + 1 + page * 128, 128);
            if (!send(packet, sizeof(packet))) {
                return false;
            }
        }
        return true;
    }

private:
    bool send(const uint8_t *bytes, size_t length)
    {
        return i2c_master_transmit(device_, bytes, length, 80) == ESP_OK;
    }

    static const uint8_t *glyph(char c)
    {
        // 5x7 glyphs from the M5StickC Plus2 node.
        static constexpr struct {
            char character;
            uint8_t rows[7];
        } font[] = {
            {'A', {0x0e, 0x11, 0x11, 0x1f, 0x11, 0x11, 0x11}},
            {'B', {0x1e, 0x11, 0x11, 0x1e, 0x11, 0x11, 0x1e}},
            {'C', {0x0f, 0x10, 0x10, 0x10, 0x10, 0x10, 0x0f}},
            {'D', {0x1e, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1e}},
            {'E', {0x1f, 0x10, 0x10, 0x1e, 0x10, 0x10, 0x1f}},
            {'F', {0x1f, 0x10, 0x10, 0x1e, 0x10, 0x10, 0x10}},
            {'G', {0x0f, 0x10, 0x10, 0x13, 0x11, 0x11, 0x0f}},
            {'H', {0x11, 0x11, 0x11, 0x1f, 0x11, 0x11, 0x11}},
            {'I', {0x1f, 0x04, 0x04, 0x04, 0x04, 0x04, 0x1f}},
            {'J', {0x01, 0x01, 0x01, 0x01, 0x11, 0x11, 0x0e}},
            {'K', {0x11, 0x12, 0x14, 0x18, 0x14, 0x12, 0x11}},
            {'L', {0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1f}},
            {'M', {0x11, 0x1b, 0x15, 0x15, 0x11, 0x11, 0x11}},
            {'N', {0x11, 0x19, 0x15, 0x13, 0x11, 0x11, 0x11}},
            {'O', {0x0e, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0e}},
            {'P', {0x1e, 0x11, 0x11, 0x1e, 0x10, 0x10, 0x10}},
            {'Q', {0x0e, 0x11, 0x11, 0x11, 0x15, 0x12, 0x0d}},
            {'R', {0x1e, 0x11, 0x11, 0x1e, 0x14, 0x12, 0x11}},
            {'S', {0x0f, 0x10, 0x10, 0x0e, 0x01, 0x01, 0x1e}},
            {'T', {0x1f, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04}},
            {'U', {0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0e}},
            {'V', {0x11, 0x11, 0x11, 0x11, 0x11, 0x0a, 0x04}},
            {'W', {0x11, 0x11, 0x11, 0x15, 0x15, 0x15, 0x0a}},
            {'X', {0x11, 0x11, 0x0a, 0x04, 0x0a, 0x11, 0x11}},
            {'Y', {0x11, 0x11, 0x0a, 0x04, 0x04, 0x04, 0x04}},
            {'Z', {0x1f, 0x01, 0x02, 0x04, 0x08, 0x10, 0x1f}},
            {'0', {0x0e, 0x11, 0x13, 0x15, 0x19, 0x11, 0x0e}},
            {'1', {0x04, 0x0c, 0x04, 0x04, 0x04, 0x04, 0x0e}},
            {'2', {0x0e, 0x11, 0x01, 0x02, 0x04, 0x08, 0x1f}},
            {'3', {0x1e, 0x01, 0x01, 0x0e, 0x01, 0x01, 0x1e}},
            {'4', {0x02, 0x06, 0x0a, 0x12, 0x1f, 0x02, 0x02}},
            {'5', {0x1f, 0x10, 0x10, 0x1e, 0x01, 0x01, 0x1e}},
            {'6', {0x0e, 0x10, 0x10, 0x1e, 0x11, 0x11, 0x0e}},
            {'7', {0x1f, 0x01, 0x02, 0x04, 0x08, 0x08, 0x08}},
            {'8', {0x0e, 0x11, 0x11, 0x0e, 0x11, 0x11, 0x0e}},
            {'9', {0x0e, 0x11, 0x11, 0x0f, 0x01, 0x01, 0x0e}},
            {':', {0x00, 0x04, 0x04, 0x00, 0x04, 0x04, 0x00}},
            {'.', {0x00, 0x00, 0x00, 0x00, 0x00, 0x0c, 0x0c}},
            {'-', {0x00, 0x00, 0x00, 0x1f, 0x00, 0x00, 0x00}},
            {'+', {0x00, 0x04, 0x04, 0x1f, 0x04, 0x04, 0x00}},
            {'/', {0x01, 0x01, 0x02, 0x04, 0x08, 0x10, 0x10}},
            {'%', {0x19, 0x19, 0x02, 0x04, 0x08, 0x13, 0x13}},
        };
        for (const auto &entry : font) {
            if (entry.character == c) {
                return entry.rows;
            }
        }
        return nullptr;
    }

    i2c_master_dev_handle_t device_ = nullptr;
    uint8_t frame_[1 + 128 * 8] = {0x40};
};
